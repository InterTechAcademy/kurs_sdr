options:
  parameters:
    generate_options: qt_gui
    id: demodulacja_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '1187.5'
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '21000'
    low_cutoff_freq: '17000'
    samp_rate: samp_rate
    type: band_pass
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq
  id: variable
  parameters:
    value: '104300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '0.05'
    min_freq: '-0.05'
    w: '0.02'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: (len(bpf)-1)//2+32
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk
    fmax: '0.01'
    fmin: '-0.01'
    loop_bw: '0.0628'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.1'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.05'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baudrate
    ted_gain: '0.2'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: '901'
    samp_rate: samp_rate
    sym_rate: baudrate*2
    type: ccc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,2,1,1)
    size: '400'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: (3,0,1,2)
    samp_per_symbol: int(samp_rate/baudrate)
    size: int(samp_rate/baudrate)*500
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    gui_hint: (1,1,1,1)
    label1: Surowy sygnał
    label2: RDS
    label3: Pilot x 3
    name: '"Sygnał zdemodulowany"'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,1)
    name: '"Sygnał zmodulowany"'
    size: samp_rate//100
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,1)
    label1: Surowy sygnał - Re
    label2: Surowy sygnał - Im
    label3: RDS - Re
    label4: RDS - Im
    label5: Pilot x 3 - Re
    label6: Pilot x 3 - Im
    name: '"Faza"'
    nconnections: '3'
    size: samp_rate//100
    srate: samp_rate
    type: complex
    ymax: '6.28'
    ymin: '-6.28'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,1,1)
    marker1: '0'
    marker2: '0'
    name: '"Symbole"'
    size: '200'
    srate: baudrate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    srate: baudrate
    type: msg_float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    gui_hint: (0,1,1,1)
    name: '"Sygnał zmodulowany"'
    type: complex
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    gui_hint: (3,2,1,1)
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rds
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: bitstream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rds
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bitstream
  states: {}

connections:
- [analog_agc_xx_0, '0', virtual_sink_0, '0']
- [analog_agc_xx_1, '0', qtgui_eye_sink_x_0, '0']
- [analog_agc_xx_1, '0', qtgui_freq_sink_x_0, '1']
- [analog_agc_xx_1, '0', qtgui_time_sink_x_0_0, '1']
- [analog_agc_xx_1, '0', virtual_sink_1, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_imag_0, '0', analog_agc_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_1, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_1, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_multiply_xx_1, '0', filter_fft_rrc_filter_0, '0']
- [digital_constellation_receiver_cb_0, '0', virtual_sink_2, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', analog_agc_xx_1, '0']
- [fir_filter_xxx_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', analog_pll_refout_cc_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rds_decoder_0, out, qtgui_time_sink_x_2, in]
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_delay_1, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_1, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_2, '0', digital_diff_decoder_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
