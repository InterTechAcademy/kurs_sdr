options:
  parameters:
    generate_options: qt_gui
    id: demodulacja_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '21000'
    low_cutoff_freq: '17000'
    samp_rate: samp_rate
    type: band_pass
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    label: Kanał
    label0: L
    label1: R
    label2: L+R
    label3: L-R
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '104300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '0.05'
    min_freq: '-0.05'
    w: '0.02'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: (len(bpf)-1)//2+32
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '20'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    gui_hint: (1,1,1,1)
    label1: Surowy sygnał
    label2: L-R
    label3: Pilot
    name: '"Sygnał zdemodulowany"'
    nconnections: '4'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,1)
    name: '"Sygnał zmodulowany"'
    size: samp_rate//100
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,1)
    label1: Surowy sygnał
    label2: L+R
    label3: Pilot
    label4: L-R
    name: '"Faza"'
    nconnections: '4'
    size: samp_rate//100
    srate: samp_rate
    type: float
    ymax: '6.28'
    ymin: '-6.28'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    gui_hint: (0,1,1,1)
    name: '"Sygnał zmodulowany"'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_delay_1, '0']
- [analog_agc_xx_0, '0', fir_filter_xxx_0, '0']
- [analog_fm_deemph_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_0, '0']
- [blocks_complex_to_imag_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_complex_to_real_0_0, '0', low_pass_filter_1_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_1, '0', blocks_float_to_complex_0, '0']
- [blocks_delay_1, '0', low_pass_filter_1, '0']
- [blocks_delay_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_0_0, '0']
- [blocks_selector_0, '0', analog_fm_deemph_0, '0']
- [blocks_sub_xx_0, '0', blocks_selector_0, '1']
- [fir_filter_xxx_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', analog_pll_refout_cc_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_1, '0', blocks_add_xx_0, '0']
- [low_pass_filter_1, '0', blocks_selector_0, '2']
- [low_pass_filter_1, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0_0, '1']
- [low_pass_filter_1_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_1_0, '0', blocks_selector_0, '3']
- [low_pass_filter_1_0, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_1_0, '0', qtgui_freq_sink_x_0, '3']
- [low_pass_filter_1_0, '0', qtgui_time_sink_x_0_0, '3']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
