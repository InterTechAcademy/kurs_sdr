options:
  parameters:
    generate_options: qt_gui
    id: demodulacja_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '7200'
  states: {}
- name: channel_select
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: Antyaliasing
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '90000000'
    step: '1000'
    stop: '200000000'
    value: '104300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: audio_samp_rate//2
    gain: '1.0'
    samp_rate: samp_rate
    width: audio_samp_rate//4
    win: window.WIN_HAMMING
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_rate//audio_samp_rate
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: samp_rate//audio_samp_rate
    taps: taps
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (1,1,1,1)
    name: '"Po demodulacji"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,0,1,1)
    size: samp_rate//100
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0,1,1,1)
    name: '"Po demodulacji"'
    size: audio_samp_rate//10
    srate: audio_samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: (1,0,1,1)
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_wfm_rcv_0, '0', fir_filter_xxx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_0, '0', blocks_selector_0, '1']
- [soapy_rtlsdr_source_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
